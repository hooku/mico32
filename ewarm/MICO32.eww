<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MICO32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MICO32_DEMO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MICO32_SPP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MICO32_WECHAT.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>MICO32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_DEMO</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_DEMO</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_SPP</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_SPP</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_WECHAT</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_WECHAT</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>dbg_demo</name>
      <member>
        <project>MICO32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_DEMO</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>dbg_spp</name>
      <member>
        <project>MICO32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_SPP</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>dbg_wechat</name>
      <member>
        <project>MICO32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>MICO32_WECHAT</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release_demo</name>
      <member>
        <project>MICO32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_DEMO</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release_spp</name>
      <member>
        <project>MICO32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_SPP</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release_wechat</name>
      <member>
        <project>MICO32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>MICO32_WECHAT</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


