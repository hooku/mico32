# IAR project MICO32_SPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; MICO32; USE_FREERTOS; DEBUG
  ICCARM.CCIncludePath2: C:\ti\CC3200SDK_1.1.0\cc3200-sdk; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\inc; ..; ..\MICO\include; ..\MICO\Bootloader; ..\MICO\External; ..\MICO\MICO; ..\MICO\Support; ..\MICO\Platform\Cortex-M4; ..\mico32_spp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MICO32_SPP.bin
  ILINK.IlinkOutputFile: MICO32_SPP.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: C:\ti\CC3200SDK_1.1.0\cc3200-sdk\example\blinky\ewarm\cc3200.icf
  ILINK.IlinkAdditionalLibs: ..\ewarm\Debug\Exe\MICO32.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\simplelink\ewarm\OS\Exe\simplelink.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; MICO32; USE_FREERTOS
  ICCARM.CCOptLevel: 2
  ILINK.IlinkAdditionalLibs: ..\ewarm\Release\Exe\MICO32.a; ..\external\airkiss\libairkiss.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\simplelink\ewarm\OS\Exe\simplelink.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a
  group application
    ../mico32_spp/: LocalTcpServer.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h RemoteTcpClient.c SppProtocol.c SppProtocol.h UartRecv.c
  group external/curve25519
    ../MICO/External/Curve25519/: curve25519-donna.c
  group external/json-c
    ../MICO/External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group external/shautils
    ../MICO/External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../MICO/include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/micodriver
    ../MICO/include/MicoDrivers/: MicoDriverUart.h
  group mico
    ../MICO/MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group mico/airkiss
    ../MICO/MICO/Airkiss/: Airkiss.c
  group mico/easylink
    ../MICO/MICO/EasyLink/: EasyLink.c
    ../MICO/MICO/SoftAP/: EasyLinkSoftAP.c
  group mico/library
    ../MICO/MICO/Library/: MICOConfig.c
  group mico/wps
    ../MICO/MICO/WPS/: WPS.c
  group platform/cc32xx
    ../: iar_mutex.c mico32_common.h
  group platform/cortex-m4
    ../MICO/Platform/Common/Cortex-M4/: crt0_IAR.c hardfault.c
  group support
    ../MICO/Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
