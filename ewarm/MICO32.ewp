# IAR project MICO32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; TARGET_IS_CC3200; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; PPP_SUPPORT; MD5_SUPPORT; MICO32; MICO32_BIG_RAM; MICO32_DEBUG; DOG_LED
  ICCARM.CCIncludePath2: C:\ti\CC3200SDK_1.1.0\cc3200-sdk; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\inc; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\simplelink\include; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\oslib; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\middleware\driver\hal; ..; ..\MICO\include; ..\MICO\Bootloader; ..\MICO\External; ..\MICO\MICO; ..\MICO\Support; ..\MICO\Platform\Cortex-M4; ..\MICO\Platform\include; ..\MICO\Demos\COM.MXCHIP.SPP; ..\FreeRTOS\source; ..\FreeRTOS\source\include; ..\FreeRTOS\source\portable\IAR\ARM_CM4; ..\lwip\src\include; ..\lwip\src\include\ipv4; ..\lwip\test\unit; ..\lwip\ports\tiva-tm4c129\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\ti\CC3200SDK_1.1.0\cc3200-sdk\third_party\FreeRTOS\source
  OBJCOPY.OOCOutputFile: MICO32.srec
  ILINK.IlinkOutputFile: mico32.out
  ILINK.IlinkAdditionalLibs: C:\ti\CC3200SDK_1.0.0\cc3200-sdk\simplelink\ewarm\OS\Exe\simplelink.a; C:\ti\CC3200SDK_1.0.0\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; MICO32; PPP_SUPPORT; MD5_SUPPORT
  ICCARM.CCIncludePath2: C:\ti\CC3200SDK_1.1.0\cc3200-sdk; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\inc; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\simplelink\include; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\oslib; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\middleware\driver\hal; ..; ..\MICO\include; ..\MICO\Bootloader; ..\MICO\External; ..\MICO\MICO; ..\MICO\Support; ..\MICO\Platform\Cortex-M4; ..\MICO\Platform\include; ..\MICO\Demos\COM.MXCHIP.SPP; ..\FreeRTOS\source; ..\FreeRTOS\source\include; ..\FreeRTOS\source\portable\IAR\ARM_CM4; ..\lwip\src\include; ..\lwip\src\include\ipv4; ..\lwip\src\netif\ppp; ..\lwip\test\unit; ..\lwip\ports\tiva-tm4c129\include
  ICCARM.CCOptLevel: 2
  group (top)
    ../: mico32_common.h mico32_easylink_lib.c mico32_entry.c mico32_hal.c mico32_handler.c mico32_handler.h mico32_md5.c mico32_misc.c mico32_osal.c mico32_sock.c mico32_wlan.c pinmux.c
  group common
    ../../../../../../../../ti/CC3200SDK_1.1.0/cc3200-sdk/example/common/: startup_ewarm.c timer_if.c uart_if.c
  group easylink library
    ../: mico32_easylink.h mico32_easylink_2.c mico32_easylink_3.c mico32_easylink_plus.c
  group external
    ../external/: airkiss.c md5.c misc.c
    ../external/airkiss/: libairkiss.a libairkiss_log.a
  group FreeRTOS
    ../FreeRTOS/source/: croutine.c FreeRTOSConfig.h list.c queue.c tasks.c timers.c
    ../FreeRTOS/source/portable/MemMang/: heap_4.c
    ../../../../../../../../ti/CC3200SDK_1.1.0/cc3200-sdk/oslib/: osi_freertos.c
    ../FreeRTOS/source/portable/IAR/ARM_CM4/: port.c portasm.s
  group lwip
    ../lwip/src/core/: def.c
    ../lwip/src/core/ipv4/: ip_addr.c
  group platform
    ../: cc32xx_platform.h platform.c platform.h platform_common_config.h
