# IAR project MICO32_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\ti\CC3200SDK_1.1.0\cc3200-sdk; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\inc; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib; ..; ..\MICO\include; ..\MICO\Bootloader; ..\MICO\External; ..\MICO\MICO; ..\MICO\Support; ..\MICO\Demos\COM.MXCHIP.SPP; ..\MICO\Platform\Cortex-M4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MICO32_DEMO.sim
  ILINK.IlinkOutputFile: MICO32_DEMO.out
  ILINK.IlinkConfigDefines: //CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\ewarm\Debug\Exe\MICO32.a; ..\external\airkiss\libairkiss.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\simplelink\ewarm\OS\Exe\simplelink.a; C:\ti\CC3200SDK_1.1.0\cc3200-sdk\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../mico32_demo/: mico32_demo.c
